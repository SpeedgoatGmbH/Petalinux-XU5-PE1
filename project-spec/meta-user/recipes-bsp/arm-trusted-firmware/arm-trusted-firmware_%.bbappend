SRC_URI_append = " file://0001-ATF-.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
