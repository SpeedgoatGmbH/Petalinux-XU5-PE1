FILESEXTRAPATHS_prepend := "${THISDIR}/gstreamer1.0:"

SRC_URI_append = " \
"
