SRC_URI_append = " file://0001-net-macb-Add-MDIO-driver-for-accessing-multiple-PHY-.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
