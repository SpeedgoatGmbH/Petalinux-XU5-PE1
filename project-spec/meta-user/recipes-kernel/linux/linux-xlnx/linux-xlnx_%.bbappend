SRC_URI += "file://user_2019-04-15-07-04-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

